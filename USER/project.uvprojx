# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE\led;..\HARDWARE\key;..\HARDWARE\beep;..\HARDWARE\delay;..\HARDWARE\usart;..\HARDWARE\hc_sr04;..\HARDWARE\oled;..\SYSTEM\sys;..\HARDWARE\dht11;..\HARDWARE\as608;..\HARDWARE\as608_usart2;..\HARDWARE\timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group HARDWARE
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/hc_sr04/: hc_sr04.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/as608_usart2/: as608_usart2.c
    ../HARDWARE/as608/: as608.c as608_func.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/oled/: oled_display.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
